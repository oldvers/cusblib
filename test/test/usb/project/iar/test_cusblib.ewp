# IAR project test_cusblib.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $CUTIES_CFG_DIR$; $HW_CFG_DIR$; $RTT_CFG_DIR$; ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\source; ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\source\log; ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos; ..\..\..\..\..\submodule\STM32F103C-Hardware\source\hardware; ..\..\..\..\..\submodule\STM32F103C-Hardware\source\hardware\config; ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos\Source\include; ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\source; ..\..\source; ..\..\source\usb; ..\..\source\usb\hid
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill_Test_RealHwTemplate.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\submodule\STM32F103C-Hardware\source\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkExtraOptions: --whole_archive ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\project\iar\build\release\exe\cuties.a; --whole_archive ..\..\..\..\..\submodule\STM32F103C-Hardware\project\iar\build\release\exe\STM32F103C-Hardware.a; --whole_archive ..\..\..\..\..\project\iar\build\release\exe\cusblib.a
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\project\iar\build\release\exe\cuties.a; ..\..\..\..\..\submodule\STM32F103C-Hardware\project\iar\build\release\exe\STM32F103C-Hardware.a; ..\..\..\..\..\project\iar\build\release\exe\cusblib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Main
    ../../../../source/: main.c
    ../../source/: mocks.c test.c
  group USB
    ../../source/usb/: usb_config.h usb_descriptor.c usb_descriptor.h
  group USB/HID
    ../../source/usb/hid/: hid.c hid.h
