<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\project\iar\cusblib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\submodule\STM32F103C-Hardware\submodule\cuties\project\iar\cuties.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\submodule\STM32F103C-Hardware\project\iar\STM32F103C-Hardware.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\test\usb\project\iar\test_cusblib.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>cuties</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>STM32F103C-Hardware</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>cusblib</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>test_cusblib</project>
                <configuration>test</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
