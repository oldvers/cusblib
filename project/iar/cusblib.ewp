# IAR project cusblib.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $USB_CFG_DIR$; ..\..\submodule\STM32F103C-Hardware\submodule\cuties\source; ..\..\submodule\STM32F103C-Hardware\source\hardware; ..\..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group USB
    ../../source/: usb_cdc_definitions.h usb_control.c usb_control.h usb_definitions.h usb_descriptor_definitions.h usb_device.c usb_device.h usb_hid_definitions.h usb_msc_definitions.h
